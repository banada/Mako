FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://pwm.cfg \
            file://usb_wifi.cfg \
"
