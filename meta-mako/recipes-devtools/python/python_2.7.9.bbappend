FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0128-match-x86_64-ctypes-find_library.patch"
