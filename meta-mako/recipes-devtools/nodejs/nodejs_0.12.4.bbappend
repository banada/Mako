FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://nodejs-0001-fix-ar.patch \
"
